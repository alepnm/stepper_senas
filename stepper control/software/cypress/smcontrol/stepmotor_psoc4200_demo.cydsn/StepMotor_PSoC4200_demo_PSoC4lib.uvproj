# Keil uVision project StepMotor_PSoC4200_demo_PSoC4lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: "IRAM(0x20000000-0x20000FFF)IROM(0x0-0x7FFF)CLOCK(48000000)CPUTYPE( "Cortex-M0") ESEL ELITTLE"
  output: StepMotor_PSoC4200_demo_PSoC4lib (library)
  group Source Files
    ./Generated_Source/PSoC4/: cyfitter_cfg.h cyfitter_cfg.c cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h PWM_OUT_A.c PWM_OUT_A.h PWM_OUT_A_aliases.h PWM_OUT_B.c PWM_OUT_B.h PWM_OUT_B_aliases.h INTERNAL_STEP_OUT.c INTERNAL_STEP_OUT.h INTERNAL_STEP_OUT_aliases.h STEP_INPUT.c STEP_INPUT.h STEP_INPUT_aliases.h DIR_INPUT.c DIR_INPUT.h DIR_INPUT_aliases.h STEP_INPUT_SOURCE.c STEP_INPUT_SOURCE.h STEP_INPUT_SOURCE_aliases.h DIR_INPUT_SOURCE.c DIR_INPUT_SOURCE.h DIR_INPUT_SOURCE_aliases.h DIR_OUT_A.c DIR_OUT_A.h DIR_OUT_A_aliases.h DIR_OUT_B.c DIR_OUT_B.h DIR_OUT_B_aliases.h DIR_REG.c DIR_REG.h cm0gcc.ld Cm0RealView.scat core_cm0_psoc4.h core_cm0.c core_cm0.h CyBootAsmGnu.s CyFlash.c CyFlash.h CyLib.c CyLib.h cyPm.c cyPm.h cytypes.h cyutils.c cypins.h project.h Clock_PWM_Main.c Clock_PWM_Main.h INTERNAL_STEP.c INTERNAL_STEP.h INTERNAL_STEP_PM.c TCPWM_2.c TCPWM_2.h TCPWM_2_PM.c TCPWM_1.c TCPWM_1.h TCPWM_1_PM.c
target Release (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: as above
  output: StepMotor_PSoC4200_demo_PSoC4lib (library)
