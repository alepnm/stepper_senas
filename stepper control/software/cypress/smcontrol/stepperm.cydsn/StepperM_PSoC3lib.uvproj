# Keil uVision project StepperM_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: StepperM_PSoC3lib (library)
  c flags: Optimize=5
  c misc: PR(${OutputDir}/${CompileFile}.lst) MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: ADC_DelSig_1.c ADC_DelSig_1.h ADC_DelSig_1_INT.c ADC_DelSig_1_PM.c ADC_DelSig_1_theACLK.c ADC_DelSig_1_theACLK.h clock_pulse_1.c clock_pulse_1.h clock_pwm.c clock_pwm.h Comp_A.c Comp_A.h Comp_A_PM.c Comp_B.c Comp_B.h Comp_B_PM.c Control_Reg_1.c Control_Reg_1.h Control_Reg_1_PM.c Control_Start.c Control_Start.h Control_Start_PM.c Curr_A_aliases.h Curr_A.c Curr_A.h Curr_B_aliases.h Curr_B.c Curr_B.h CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc CyBootAsmKeil.a51 cyPm.c cyPm.h isr_pwm.c isr_pwm.h isr_timer.c isr_timer.h LCD.c LCD.h LCD_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h PGA_1.c PGA_1.h PGA_1_PM.c PGA_2.c PGA_2.h PGA_2_PM.c Pot_aliases.h Pot.c Pot.h PWM_1H.c PWM_1H.h PWM_1H_aliases.h PWM_1L.c PWM_1L.h PWM_1L_aliases.h PWM_2H.c PWM_2H.h PWM_2H_aliases.h PWM_2L.c PWM_2L.h PWM_2L_aliases.h PWM_3H.c PWM_3H.h PWM_3H_aliases.h PWM_3L.c PWM_3L.h PWM_3L_aliases.h PWM_4H.c PWM_4H.h PWM_4H_aliases.h PWM_4L.c PWM_4L.h PWM_4L_aliases.h PWM_A.c PWM_A.h PWM_A_PM.c PWM_B.c PWM_B.h PWM_B_PM.c Switch1.c Switch1.h Switch1_aliases.h Switch2.c Switch2.h Switch2_aliases.h Timer_1.c Timer_1.h Timer_1_PM.c UART_1.c UART_1.h UART_1_INT.c UART_1_PM.c UART_1_BOOT.c UART_1_IntClock.c UART_1_IntClock.h UART_IN.c UART_IN.h UART_IN_aliases.h UART_OUT.c UART_OUT.h UART_OUT_aliases.h VDAC8_IrefA.c VDAC8_IrefA.h VDAC8_IrefA_PM.c VDAC8_IrefB.c VDAC8_IrefB.h VDAC8_IrefB_PM.c cydevice.h cydevice_trm.h cydevicekeil.inc cydevicekeil_trm.inc cyfitter.h cyfitter_cfg.c cyfitter_cfg.h cyfitterkeil.inc project.h cydisabledsheets.h ADC_DelSig_1_AMux.c ADC_DelSig_1_AMux.h ADC_DelSig_1_Ext_CP_Clk.c ADC_DelSig_1_Ext_CP_Clk.h ADC_DelSig_1_IRQ.c ADC_DelSig_1_IRQ.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: StepperM_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
