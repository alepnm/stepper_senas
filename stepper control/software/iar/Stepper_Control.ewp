# IAR project Stepper_Control.ewp, settings and files
configuration ATMEGA8 (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x10
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x10
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m8 ATmega8
  ICCAVR.CCDefines: F_CPU=8000000UL
  ICCAVR.newCCIncludePaths: ; freemodbus\; freemodbus\modbus\include\; freemodbus\modbus\rtu\; freemodbus\port\; freemodbus\port\Atmega
  ICCAVR.PreInclude: bendra.h
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  prebuild: wscript.exe versionfile-gen.vbs version.h
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm8s.xcl
  XLINK.XExtraOptions: -Ointel-standard,(CODE)=.flash.hex; -Ointel-standard,(XDATA)=.eeprom.hex
configuration ATMEGA328 (AVR, debug)
  as the first configuration, except:
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x20
  General.GenDeviceSelectMenu: m328p ATmega328P
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm328ps.xcl
configuration ATMEGA16 (AVR, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: m16 ATmega16
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm16s.xcl
  group (top)
    ./: eeprom.c func.c interrupts.c main.c stepper.c systick.c version.h
    FREEMODBUS/: user_mb_app.c
  group examples
    ./: temp_conv.c
  group freemodbus/modbus
    FREEMODBUS/modbus/: mb.c
    FREEMODBUS/modbus/rtu/: mbcrc.c mbrtu.c
    FREEMODBUS/modbus/FUNCTIONS/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    freemodbus/modbus/functions/: mbfuncdiag.c
  group freemodbus/port
    freemodbus/port/: portevent.c
    FREEMODBUS/port/: portserial.c porttimer.c
  group kita
    ./: keywords.txt versionfile-gen.vbs
    ../../../Stendas/2.0/MbModule/software/MbModule/: ocr_skaiciavimai.c
